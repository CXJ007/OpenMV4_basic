# Repository CXJ007/OpenMV4_basic

File README.md:

# OpenMV4_basic
支持ov7725和ov2640刷固件就用那个压缩包去openmv ide文件夹找到bin文件然后下载教程网上都就不重复造轮子了  
这个应该挺简单的反正pcb就是连通就行了感觉没啥注意的就关注一下摄像头那个几个电压  
可以不用tps731太贵了tb好买到假的 比如sy8088代替  
typec那个cc没下拉不过和电脑A口连问题不大  

b站：https://www.bilibili.com/video/BV1XT4y1o7vJ?from=search&seid=12204164981700961731&spm_id_from=333.337.0.0

## KiCad design openmv4/openmv4.kicad_pcb

Parts:
C1, C2, C3, C4, C5, C6, C7, C14, C16: 0.1uf; C_0805_2012Metric
C8: 47uf; C_0805_2012Metric
C9: 1uf; C_0805_2012Metric
C10, C12: 2.2uf; C_0805_2012Metric
C11, C13: 12pf; C_0805_2012Metric
C15, C18: 22uf; C_0805_2012Metric
C17: 0.1u; C_0805_2012Metric
C19, C20: 1u; C_0805_2012Metric
D1: LED_R; LED_0805_2012Metric
D2: LED_G; LED_0805_2012Metric
D3: LED_B; LED_0805_2012Metric
D4, D5: SS34
F1: FPC_24; FPC_24_0.5
J1, J2: Conn_01x06_Male; 6p_2.54
J3: Conn_01x08_Male; 8p_2.54
J4, J5, J6: Conn_01x02_Male; 2p_2.54
L1: mpz1608s181atah0
R1, R5, R6, R7, R8, R9, R10, R13: 10k; R_0805_2012Metric
R2, R3, R4: 5k; R_0805_2012Metric
R11, R12: 4.7K; R_0805_2012Metric
R14: 22k; R_0805_2012Metric
R15: 56.2k; R_0805_2012Metric
R16: 44.2k; R_0805_2012Metric
R17: 33.2k; R_0805_2012Metric
SW1: SW
U2: STM32H743VITx; LQFP-100_14x14mm_P0.5mm
U4: Micro_SD_Card; Micro_SD
U5: ME6212C33M5G; SOT-23-5
U6, U7: TPS731xx; SOT-23-5
U8: TYPE-C-31-M-12_母座; typec 12
Y1: 12.00MHZ; X332512MSB4S

Connections:
+2V8: C20.1, F1.4, F1.11, R16.1, U7.5 (OUT)
+3V3: C2.2, C3.2, C4.2, C5.2, C6.2, C7.2, C8.1, C14.1, C18.1, D1.2 (A), D2.2 (A), D3.2 (A), J2.5, L1.2, R5.1, R6.1, R7.1, R8.2, R9.1, R10.1, R11.2, R12.2, R13.1, U2.6 (VBAT), U2.11 (VDD), U2.27 (VDD), U2.50 (VDD), U2.75 (VDD), U2.100 (VDD), U4.4 (VDD), U5.5 (VOUT), U6.1 (IN), U6.3 (EN), U7.1 (IN), U7.3 (EN)
+5V: C15.1, C16.1, D4.1, D5.1, U5.1 (VIN), U5.3 (CE)
/1: J5.1, J6.1, U6.4 (NR/FB)
/2: J6.2, R14.2, R15.1
/3: C19.1, F1.10, J5.2, R14.1, U6.5 (OUT)
/5V: D5.2, U2.68 (PA9), U8.A4 (VBUS), U8.A9 (VBUS), U8.B4 (VBUS), U8.B9 (VBUS)
/A: C1.2, C9.1, L1.1, U2.20 (VREF+), U2.21 (VDDA)
/BOOT0: J1.1, R1.1, U2.94 (BOOT0)
/DAC: J1.5, U2.29 (PA5)
/DCMI_CLK: F1.13, U2.67 (PA8)
/DCMI_D0: F1.19, U2.63 (PC6)
/DCMI_D1: F1.21, U2.64 (PC7)
/DCMI_D2: F1.22, U2.97 (PE0)
/DCMI_D3: F1.20, U2.98 (PE1)
/DCMI_D4: F1.18, U2.3 (PE4)
/DCMI_D5: F1.16, U2.92 (PB6)
/DCMI_D6: F1.14, U2.4 (PE5)
/DCMI_D7: F1.12, U2.5 (PE6)
/DCMI_HSYNC: F1.9, U2.28 (PA4)
/DCMI_PCLK: F1.17, U2.30 (PA6)
/DCMI_PWDN: F1.8, U2.88 (PD7)
/DCMI_RST: F1.6, U2.69 (PA10)
/DCMI_VSYNC: F1.7, U2.93 (PB7)
/I2C1_SCL: F1.5, R11.1, U2.95 (PB8)
/I2C1_SDA: F1.3, R12.1, U2.96 (PB9)
/I2C2_SCL: J3.5, U2.46 (PB10)
/I2C2_SDA: J3.6, U2.47 (PB11)
/LED_B: R4.1, U2.17 (PC2_C)
/LED_G: R3.1, U2.16 (PC1)
/LED_R: R2.1, U2.15 (PC0)
/NRST: C17.1, J2.4, R13.2, SW1.2 (B), U2.14 (NRST)
/SDIO_CLK: U2.80 (PC12), U4.5 (CLK)
/SDIO_CMD: R7.2, U2.83 (PD2), U4.3 (CMD)
/SDIO_D0: R8.1, U2.65 (PC8), U4.7 (DAT0)
/SDIO_D1: R9.2, U2.66 (PC9), U4.8 (DAT1)
/SDIO_D2: R5.2, U2.78 (PC10), U4.1 (DAT2)
/SDIO_D3: R6.2, U2.79 (PC11), U4.2 (CD/DAT3)
/SD_CD: R10.2, U2.81 (PD0), U4.9 (CARD_CD)
/SPI2_MISO: J3.2, U2.53 (PB14)
/SPI2_MOSI: J3.1, U2.54 (PB15)
/SPI2_NSS: J3.4, U2.51 (PB12)
/SPI2_SCLK: J3.3, U2.52 (PB13)
/SPI3_SCLK/TRACFSWO: J2.1, U2.89 (PB3)
/SWCLK: J2.2, U2.76 (PA14)
/SWDIO: J2.3, U2.72 (PA13)
/TIM4_CH1: J1.4, U2.59 (PD12)
/TIM4_CH2: J1.3, U2.60 (PD13)
/TIM4_CH3: J1.2, U2.61 (PD14)
/USB_DN: U2.70 (PA11), U8.A7 (DN1), U8.B7 (DN2)
/USB_DP: U2.71 (PA12), U8.A6 (DP1), U8.B6 (DP2)
/VIN: D4.2, J3.8, J4.1
GND: C1.1, C2.1, C3.1, C4.1, C5.1, C6.1, C7.1, C8.2, C9.2, C10.2, C11.2, C12.2, C13.2, C14.2, C15.2, C16.2, C17.2, C18.2, C19.2, C20.2, F1.0, F1.2, F1.15, J1.6, J2.6, J3.7, J4.2, R1.2, R15.2, R17.2, SW1.1 (A), U2.10 (VSS), U2.19 (VSSA), U2.26 (VSS), U2.49 (VSS), U2.74 (VSS), U2.99 (VSS), U4.6 (VSS), U4.10 (SHIELD), U5.2 (VSS), U6.2 (GND), U7.2 (GND), U8.0, U8.A1 (GND), U8.A12 (GND), U8.B1 (GND), U8.B12 (GND), Y1.2
unnamed: C10.1, U2.73 (VCAP2)
unnamed: C11.1, U2.13 (PH1), Y1.1
unnamed: C12.1, U2.48 (VCAP1)
unnamed: C13.1, U2.12 (PH0), Y1.3
unnamed: D1.1 (K), R2.2
unnamed: D2.1 (K), R3.2
unnamed: D3.1 (K), R4.2
unnamed: R16.2, R17.1, U7.4 (NR/FB)

Notes on the sheet:
MCU
SD_CARD
LED
ov7725/0v2640
power
ov2640
ov7725
两个二选一

Board: 2 copper layers, 35.0 x 50.0 mm, 58 parts (1 on the bottom side), 61 nets.

## Commit log

2021-10-18 openmv4
